# Keil uVision project ProjectFiles.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ProjectFiles
  c flags: Optim=1
  c include: ..\FWlib\StartUp;..\FWlib;..\Driver;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../FWlib/StartUp/: startup_stm32f10x_md.s
    ../FWlib/: core_cm3.c
  group User
    ../User/: main.c stm32f10x_it.c
  group FWLib
    ../FWlib/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c stm32f10x_usart.c stm32f10x_can.c
  group Driver
    ../Driver/: delay.c USART1.c CAN.c LED.c
  group Doc
    ../Doc/: Readme.txt
